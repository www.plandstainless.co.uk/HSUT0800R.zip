Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-02-08T15:36:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.1.367 - Exporter 22.0.1.367 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 08 15:36:27 2022 * Host: Dean-Dell-Precision-3551 * Database: C:\Users\DEANJO~1.PLA\AppData\Local\Temp\02abed5f-6c46-49bf-9b77-dd0178894942\f331ecad-6738-4a95-aefd-272cfff7a3a8\ifc * Database version: 5507 * Database creation date: Tue Feb 08 15:36:22 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 08 15:36:22 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 08 15:36:22 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcBuildingElementProxy: Family1:Standard, Family1:Standard:207243
In: Level 1
Type - Material: 153_153_153
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connector_1_Diameter: 41.5 mm
Type - Identity Data - Description: SURGEONS SCRUB UP TROUGH; Manufacturer: PLAND STAINLESS Ltd; Model: HSUT0800R; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Standard; URL: www.plandstainless.co.uk
Type - Model Properties - Area: 1.99751 m2; Author: DeanJohnson; Catalog web link: www.plandstainless.co.uk; Category: Healthcare; Center of Gravity: X: -114.492 mm Y: 82.970 mm Z: 392.976 mm; COBie AssetType: Fixed; COBie BarCode: 5060021231550; COBie CreatedBy: Dean Johnson; COBie Description: HTM64 Scrub up Trough; COBie DocumentationLiterature: www.plandstainless.co.uk; COBie DurationUnit: Years; COBie ExpectedLife: 30; COBie Features: Right Hand Waste; COBie Finish: Satin/polished; COBie Grade: 304 1.4301; COBie Manufacturer: Plandstainless Ltd; COBie Material: Stainless Steel; COBie Model: Trinidad; COBie ModelNumber: HSUT0800R; COBie Size: 800 x 400mm; COBie WarrantyDescription: Manufacturer's Warranty; COBie WarrantyDurationUnit: Years; COBie WarrantyDurrationParts: 2; COBie WarrantyGuarantorParts: YES; Company: Pland Stainless Ltd; Date Created: 08/02/2022 00:00:00; Density: 8000 kg/m3; Designer: DeanJohnson; Design Status: 3; Mass: 15.932 kg; Material: Stainless Steel; Part Number: HSUT0800R; Requested Accuracy: Low; Stock Number: HSUT0800R; Vendor: PLAND STAINLESS Ltd; Volume: 0.0019915 m3
Type - Other - Category: Specialty Equipment; Family Name: Family1
Type - Pset_ManufacturerTypeInformation - Manufacturer: PLAND STAINLESS Ltd
Type - Pset_ProductRequirements - Category: Healthcare
Material: 153_153_153, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.998808 m2; Volume: 0.00199315 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_207243
Description: Flow; FlowDirection: SINK
